# IAR project GN_Project_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.3\common\bin; C:\dev\libs\ST\stm32\stm32g0xx\CMSIS\Device\ST\STM32G0xx\Include; C:\dev\libs\ST\stm32\stm32g0xx\CMSIS\Include; C:\dev\libs\ST\stm32\stm32g0xx\STM32G0xx_HAL_Driver\Inc; C:\dev\libs\utilities\utilities-0.0.2\inc; C:\GN_Project\src\main; C:\GN_Project\src\adc; C:\GN_Project\src\sys; C:\GN_Project\src\gpio; C:\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GN_Project_IAR.srec
  ILINK.IlinkOutputFile: GN_Project_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group adc
    ../GN_Project_Test/src/adc/: adc.c adc_.h adc_api.h adc_internal.h
  group bin
    bin/: Smart_Breaker_2_0.sim
  group gpio
    src/gpio/: gpio.c gpio_.h gpio_api.h gpio_internal.h
  group src/config/SB/2_pole/GFCI
    src/config/SB/2_pole/GFCI/: sb2-0_2p_gfci_hardware_init.c
  group src/main
    src/main/: main.c main.h main_api.h main_internal.h
  group src/sys
    src/sys/: firmware_config_common.h hardware_init.c startup_stm32g071xx.s syscalls.c sysmem.c
